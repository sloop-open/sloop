# Keil uVision project project.uvprojx, settings and files
target project (6220000::V6.22::ARMCLANG)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\Config\inc;..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\user;..\user\sloop\RTT;..\user\service\app_service_pack;..\user\service\mcu_service_pack;..\user\sloop;..\user\sloop\mcu_interface;..\user\sloop\kernel;..\user\service;..\user\service\app_service_pack\can1;..\user\service\app_service_pack\can2;..\user\service\app_service_pack\uart1;..\user\service\app_service_pack\uart2;..\user\service\app_service_pack\uart3;..\user\service\app_service_pack\uart4;..\user\service\app_service_pack\uart5;..\user\service\app_service_pack\uart6;..\user\app;..\user\app\config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group cmsis
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group std_driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_rcc.c stm32f2xx_gpio.c stm32f2xx_tim.c stm32f2xx_exti.c stm32f2xx_syscfg.c stm32f2xx_usart.c stm32f2xx_can.c stm32f2xx_iwdg.c stm32f2xx_flash.c stm32f2xx_dma.c stm32f2xx_adc.c stm32f2xx_crc.c stm32f2xx_dac.c stm32f2xx_spi.c
  group mcu_base
    ../user/sloop/mcu_interface/: mcu_base_timer.c stm32f2xx_it.c
  group sloop
    ../user/sloop/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../user/sloop/kernel/: sloop.c console.c
  group service
    ../user/service/app_service_pack/can1/: asp_can1.c
    ../user/service/mcu_service_pack/: msp_flash.c
    ../user/service/app_service_pack/: asp_run_led.c asp_beep.c asp_i2c.c asp_eep24c64.c
  group can1
    ../user/service/app_service_pack/can1/: asp_can1_receive.c asp_can1_rx_fifo.c asp_can1_send.c asp_can1_tx_fifo.c
    ../user/service/mcu_service_pack/: msp_can1.c
  group can2
    ../user/service/app_service_pack/can2/: asp_can2.c asp_can2_receive.c asp_can2_rx_fifo.c asp_can2_send.c asp_can2_tx_fifo.c
    ../user/service/mcu_service_pack/: msp_can2.c
  group uart1
    ../user/service/mcu_service_pack/: msp_uart1.c
    ../user/service/app_service_pack/uart1/: asp_uart1.c asp_uart1_receive.c asp_uart1_rx_fifo.c asp_uart1_send.c asp_uart1_tx_fifo.c
  group uart2
    ../user/service/mcu_service_pack/: msp_uart2.c
    ../user/service/app_service_pack/uart2/: asp_uart2.c asp_uart2_receive.c asp_uart2_rx_fifo.c asp_uart2_send.c asp_uart2_tx_fifo.c
  group uart3
    ../user/service/mcu_service_pack/: msp_uart3.c
    ../user/service/app_service_pack/uart3/: asp_uart3.c asp_uart3_receive.c asp_uart3_rx_fifo.c asp_uart3_send.c asp_uart3_tx_fifo.c
  group uart4
    ../user/service/mcu_service_pack/: msp_uart4.c
    ../user/service/app_service_pack/uart4/: asp_uart4.c asp_uart4_receive.c asp_uart4_rx_fifo.c asp_uart4_send.c asp_uart4_tx_fifo.c
  group uart5
    ../user/service/mcu_service_pack/: msp_uart5.c
    ../user/service/app_service_pack/uart5/: asp_uart5.c asp_uart5_receive.c asp_uart5_rx_fifo.c asp_uart5_send.c asp_uart5_tx_fifo.c
  group uart6
    ../user/service/mcu_service_pack/: msp_uart6.c
    ../user/service/app_service_pack/uart6/: asp_uart6.c asp_uart6_receive.c asp_uart6_rx_fifo.c asp_uart6_send.c asp_uart6_tx_fifo.c
  group app
    ../user/app/: main.c
    ../user/app/tasks/: task_baseInit.c task_demo.c task_idle.c
    ../user/app/config/: gpio_config.c
  group readme
    ../: readme.txt
